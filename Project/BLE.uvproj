# Keil uVision project BLE.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UAST1 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\BEEP;..\USER\KEY;..\USER\LED;..\USER\usart3_ble;..\USER\LCD;..\USER\DS18B20;..\USER\RTC;..\USER\MPU6050;..\USER\GSM;..\USER\ADC;..\USER\RS485;..\USER\INF;..\USER\RS232;..\USER\Sensor;..\USER\24C02;..\USER\W25QXX;..\USER\SPI;..\USER\HCSR04;..\USER\RS485
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group USER
    ../USER/KEY/: key.c
    ../USER/LED/: led.c
    ../USER/LCD/: lcd.c
    ../USER/BEEP/: beep.c
    ../USER/RTC/: rtc.c
    ../USER/DS18B20/: DS18B20.c
    ../USER/usart3_ble/: usart3_ble.c
    ../USER/MPU6050/: mpu6050.c
    ../USER/GSM/: gsm.c
    ../USER/ADC/: adc.c
    ../USER/RS485/: rs485.c
    ../USER/INF/: inf.c
    ../USER/RS232/: usart1.c
    ../USER/24C02/: 24c02.c eeprom.c EIIC.c
    ../USER/SPI/: spi.c
    ../USER/W25QXX/: w25qxx.c
    ../USER/Sensor/: Sensor.c cJSON.c malloc.c s2j.c
    ../USER/HCSR04/: timer.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_exti.c stm32f4xx_adc.c stm32f4xx_spi.c stm32f4xx_tim.c
  group Common
    ../Common/: common.c
